# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: IO-LED +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group User
    ./: main.c
  group Drive
    ./: STC8G_H_Soft_I2C.c ADC.c I2C.c UART.C delay.c GPIO.c
  group App
    ./: Max30102.c oled.c
